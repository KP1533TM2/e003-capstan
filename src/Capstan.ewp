# IAR project Capstan.ewp, settings and files
configuration Release (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x100
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m2560 ATmega2560
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm88pa.xcl
  group (top)
    ./: control.cpp dpll.cpp eeprom.cpp main.cpp port.cpp pwm.cpp systimer.cpp wake.cpp wakeport.cpp
